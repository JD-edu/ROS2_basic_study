Commit message: July 30th

File: ros_dd/urdf/ros_dd.urdf (robot description, URDF)
Before this commit: robot ros_dd, 5 links, 4 joints
Links:
- removed link wheel4_link
Joints:
- removed joint wheel4_joint
